

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO oadm_dm 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.03 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.132 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.898 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9952 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.958 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2592 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0996 LAYER M5 ; 
    ANTENNAMAXAREACAR 11.7269 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 52.7149 LAYER M5 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA5 ;
  END clk
  PIN x[31] 
    ANTENNAPARTIALMETALAREA 0.579 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5476 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M3 ; 
    ANTENNAMAXAREACAR 28.2692 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 124.821 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.732601 LAYER VIA3 ;
  END x[31]
  PIN x[30] 
    ANTENNAPARTIALMETALAREA 0.709 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1636 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 33.374 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 147.789 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[30]
  PIN x[29] 
    ANTENNAPARTIALMETALAREA 0.409 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8436 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 25.2439 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 112.016 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[29]
  PIN x[28] 
    ANTENNAPARTIALMETALAREA 0.429 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9316 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 28.4959 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 126.325 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[28]
  PIN x[27] 
    ANTENNAPARTIALMETALAREA 0.516 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3584 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 25.2846 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 113.984 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[27]
  PIN x[26] 
    ANTENNAPARTIALMETALAREA 0.733 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2692 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 15.2839 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 68.3663 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[26]
  PIN x[25] 
    ANTENNAPARTIALMETALAREA 0.169 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7876 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 22.8618 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 97.7886 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[25]
  PIN x[24] 
    ANTENNAPARTIALMETALAREA 0.509 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2836 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 25 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 110.943 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[24]
  PIN x[23] 
    ANTENNAPARTIALMETALAREA 0.62 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.728 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.138 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6512 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 6.68498 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 30.4689 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.549451 LAYER VIA4 ;
  END x[23]
  PIN x[22] 
    ANTENNAPARTIALMETALAREA 0.633 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8292 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 6.81181 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 30.533 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[22]
  PIN x[21] 
    ANTENNAPARTIALMETALAREA 0.869 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8676 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 20.1807 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 89.261 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END x[21]
  PIN x[20] 
    ANTENNAPARTIALMETALAREA 0.415 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.826 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 21.1789 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 92.3415 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[20]
  PIN x[19] 
    ANTENNAPARTIALMETALAREA 0.599 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6356 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M3 ; 
    ANTENNAMAXAREACAR 25.4908 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 113.26 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.732601 LAYER VIA3 ;
  END x[19]
  PIN x[18] 
    ANTENNAPARTIALMETALAREA 0.669 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9876 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 35.813 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 158.52 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[18]
  PIN x[17] 
    ANTENNAPARTIALMETALAREA 0.399 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7556 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 26.4634 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 115.593 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[17]
  PIN x[16] 
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.158 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7392 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M4 ; 
    ANTENNAMAXAREACAR 21.3828 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 96.0073 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.549451 LAYER VIA4 ;
  END x[16]
  PIN x[15] 
    ANTENNAPARTIALMETALAREA 1.007 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5188 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 21.1447 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 94.9597 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[15]
  PIN x[14] 
    ANTENNAPARTIALMETALAREA 0.419 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8436 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 22.3984 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 97.7073 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END x[14]
  PIN x[13] 
    ANTENNAPARTIALMETALAREA 0.896 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0304 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 18.4908 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 82.6374 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[13]
  PIN x[12] 
    ANTENNAPARTIALMETALAREA 0.747 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3748 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 16.2381 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 72.7253 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[12]
  PIN x[11] 
    ANTENNAPARTIALMETALAREA 0.529 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3716 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M3 ; 
    ANTENNAMAXAREACAR 23.1465 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 104.557 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.732601 LAYER VIA3 ;
  END x[11]
  PIN x[10] 
    ANTENNAPARTIALMETALAREA 0.659 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8996 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 23.0513 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 101.092 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[10]
  PIN x[9] 
    ANTENNAPARTIALMETALAREA 0.749 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3396 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 22.1355 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 97.8681 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[9]
  PIN x[8] 
    ANTENNAPARTIALMETALAREA 0.018 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1232 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 14.707 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 62.4396 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END x[8]
  PIN x[7] 
    ANTENNAPARTIALMETALAREA 0.587 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6708 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 6.39057 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 29.0824 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[7]
  PIN x[6] 
    ANTENNAPARTIALMETALAREA 0.489 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1956 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 13.6067 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 60.4304 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[6]
  PIN x[5] 
    ANTENNAPARTIALMETALAREA 0.256 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2144 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 3.35943 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 15.7454 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[5]
  PIN x[4] 
    ANTENNAPARTIALMETALAREA 0.449 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 6.83013 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 30.6136 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[4]
  PIN x[3] 
    ANTENNAPARTIALMETALAREA 0.687 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1108 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 7.54441 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 34.1593 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[3]
  PIN x[2] 
    ANTENNAPARTIALMETALAREA 0.967 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3428 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 9.87042 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 44.3938 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END x[2]
  PIN x[1] 
    ANTENNAPARTIALMETALAREA 0.689 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0756 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 22.1084 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 97.743 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END x[1]
  PIN x[0] 
    ANTENNAPARTIALMETALAREA 0.529 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3716 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 20.9036 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 92.4418 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END x[0]
  PIN y[31] 
    ANTENNAPARTIALMETALAREA 0.509 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2836 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 29.3089 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 129.902 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[31]
  PIN y[30] 
    ANTENNAPARTIALMETALAREA 0.847 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8148 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 47.1138 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 210.033 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[30]
  PIN y[29] 
    ANTENNAPARTIALMETALAREA 0.018 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1232 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 37.9431 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 161.512 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[29]
  PIN y[28] 
    ANTENNAPARTIALMETALAREA 0.469 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1076 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 43.9431 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 194.293 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[28]
  PIN y[27] 
    ANTENNAPARTIALMETALAREA 0.029 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1716 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 20.6667 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 86.0813 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[27]
  PIN y[26] 
    ANTENNAPARTIALMETALAREA 0.749 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3396 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 54.5122 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 240.797 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[26]
  PIN y[25] 
    ANTENNAPARTIALMETALAREA 0.589 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6356 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 59.3902 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 262.26 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[25]
  PIN y[24] 
    ANTENNAPARTIALMETALAREA 0.547 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4948 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 29.2276 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 131.333 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[24]
  PIN y[23] 
    ANTENNAPARTIALMETALAREA 0.649 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8996 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 13.7454 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 61.5971 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[23]
  PIN y[22] 
    ANTENNAPARTIALMETALAREA 0.619 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7236 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.258 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1792 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M4 ; 
    ANTENNAMAXAREACAR 3.85394 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 17.9212 LAYER M4 ;
    ANTENNAMAXCUTCAR 0.274725 LAYER VIA4 ;
  END y[22]
  PIN y[21] 
    ANTENNAPARTIALMETALAREA 0.449 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 14.0763 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 62.4016 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END y[21]
  PIN y[20] 
    ANTENNAPARTIALMETALAREA 0.307 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4388 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 9.42308 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 43.3846 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[20]
  PIN y[19] 
    ANTENNAPARTIALMETALAREA 0.689 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0756 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 14.6996 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 65.1502 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[19]
  PIN y[18] 
    ANTENNAPARTIALMETALAREA 0.809 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6036 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 17.0073 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 75.304 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[18]
  PIN y[17] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 8.77289 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 35.5238 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[17]
  PIN y[16] 
    ANTENNAPARTIALMETALAREA 0.018 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1232 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 9.21245 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 38.2637 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[16]
  PIN y[15] 
    ANTENNAPARTIALMETALAREA 0.489 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1956 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 10.9038 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 49.1538 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END y[15]
  PIN y[14] 
    ANTENNAPARTIALMETALAREA 0.489 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1956 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 24.4309 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 108.439 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END y[14]
  PIN y[13] 
    ANTENNAPARTIALMETALAREA 0.019 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0836 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 10.008 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 40.755 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END y[13]
  PIN y[12] 
    ANTENNAPARTIALMETALAREA 0.78 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.432 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 17.9116 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 78.3936 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END y[12]
  PIN y[11] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0498 LAYER M3 ; 
    ANTENNAMAXAREACAR 10.7912 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 44.0562 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.401606 LAYER VIA3 ;
  END y[11]
  PIN y[10] 
    ANTENNAPARTIALMETALAREA 0.569 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5476 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 6.22573 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 27.9542 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END y[10]
  PIN y[9] 
    ANTENNAPARTIALMETALAREA 0.409 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8436 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M3 ; 
    ANTENNAMAXAREACAR 23.9304 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 107.267 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.732601 LAYER VIA3 ;
  END y[9]
  PIN y[8] 
    ANTENNAPARTIALMETALAREA 0.399 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7556 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 4.85119 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 21.3938 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END y[8]
  PIN y[7] 
    ANTENNAPARTIALMETALAREA 0.729 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2516 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 8.47756 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 37.7527 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END y[7]
  PIN y[6] 
    ANTENNAPARTIALMETALAREA 0.429 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9316 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0996 LAYER M3 ; 
    ANTENNAMAXAREACAR 5.43173 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 24.1325 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.200803 LAYER VIA3 ;
  END y[6]
  PIN y[5] 
    ANTENNAPARTIALMETALAREA 0.572 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5608 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0273 LAYER M3 ; 
    ANTENNAMAXAREACAR 24.978 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 112.615 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.732601 LAYER VIA3 ;
  END y[5]
  PIN y[4] 
    ANTENNAPARTIALMETALAREA 0.018 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1232 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 4.94643 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 20.8443 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END y[4]
  PIN y[3] 
    ANTENNAPARTIALMETALAREA 0.409 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8436 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0996 LAYER M3 ; 
    ANTENNAMAXAREACAR 6.63655 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 29.4337 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.200803 LAYER VIA3 ;
  END y[3]
  PIN y[2] 
    ANTENNAPARTIALMETALAREA 0.569 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5476 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1092 LAYER M3 ; 
    ANTENNAMAXAREACAR 6.46291 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 28.8883 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.18315 LAYER VIA3 ;
  END y[2]
  PIN y[1] 
    ANTENNAPARTIALMETALAREA 0.749 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3396 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0996 LAYER M3 ; 
    ANTENNAMAXAREACAR 10.0502 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 44.4538 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.200803 LAYER VIA3 ;
  END y[1]
  PIN y[0] 
    ANTENNAPARTIALMETALAREA 0.419 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8436 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0996 LAYER M3 ; 
    ANTENNAMAXAREACAR 5.63303 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 24.259 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.200803 LAYER VIA3 ;
  END y[0]
  PIN level[1] 
    ANTENNAPARTIALMETALAREA 0.137 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6908 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 4.72527 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 21.1429 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END level[1]
  PIN level[0] 
    ANTENNAPARTIALMETALAREA 0.277 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3068 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0546 LAYER M3 ; 
    ANTENNAMAXAREACAR 7.0696 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 32.1612 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.3663 LAYER VIA3 ;
  END level[0]
  PIN divide_mode 
    ANTENNAPARTIALMETALAREA 0.137 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6908 LAYER M3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0246 LAYER M3 ; 
    ANTENNAMAXAREACAR 9.87805 LAYER M3 ;
    ANTENNAMAXSIDEAREACAR 46.1951 LAYER M3 ;
    ANTENNAMAXCUTCAR 0.813008 LAYER VIA3 ;
  END divide_mode
  PIN result[31] 
    ANTENNAPARTIALMETALAREA 0.239 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0516 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.058 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2992 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 2.558 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2992 LAYER M5 ;
  END result[31]
  PIN result[30] 
    ANTENNAPARTIALMETALAREA 0.737 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2868 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.238 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0912 LAYER M4 ;
  END result[30]
  PIN result[29] 
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.338 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5312 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 1.998 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.8352 LAYER M5 ;
  END result[29]
  PIN result[28] 
    ANTENNAPARTIALMETALAREA 0.159 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6996 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.798 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5552 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.0678 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 1.978 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7472 LAYER M5 ;
  END result[28]
  PIN result[27] 
    ANTENNAPARTIALMETALAREA 0.319 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4036 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.338 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5312 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 1.538 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8112 LAYER M5 ;
  END result[27]
  PIN result[26] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 2.025 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.042 LAYER M3 ;
  END result[26]
  PIN result[25] 
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.298 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3552 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 2.598 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4752 LAYER M5 ;
  END result[25]
  PIN result[24] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.887 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3908 LAYER M3 ;
  END result[24]
  PIN result[23] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.176 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2624 LAYER M3 ;
  END result[23]
  PIN result[22] 
    ANTENNAPARTIALMETALAREA 0.279 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2276 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.078 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3872 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 1.938 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5712 LAYER M5 ;
  END result[22]
  PIN result[21] 
    ANTENNAPARTIALMETALAREA 2.579 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3476 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.838 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7312 LAYER M4 ;
  END result[21]
  PIN result[20] 
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.178 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8272 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 2.658 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7392 LAYER M5 ;
  END result[20]
  PIN result[19] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.429 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3316 LAYER M3 ;
  END result[19]
  PIN result[18] 
    ANTENNAPARTIALMETALAREA 0.371 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6764 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNAPARTIALMETALAREA 0.052 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2728 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA4 ;
    ANTENNADIFFAREA 0.077 LAYER M5 ; 
    ANTENNAPARTIALMETALAREA 1.218 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4032 LAYER M5 ;
  END result[18]
  PIN result[17] 
    ANTENNAPARTIALMETALAREA 1.579 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9476 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.1502 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.098 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4752 LAYER M4 ;
  END result[17]
  PIN result[16] 
    ANTENNAPARTIALMETALAREA 2 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.8 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.278 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6672 LAYER M4 ;
  END result[16]
  PIN result[15] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.849 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1796 LAYER M3 ;
  END result[15]
  PIN result[14] 
    ANTENNAPARTIALMETALAREA 1.739 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.6516 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.498 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6352 LAYER M4 ;
  END result[14]
  PIN result[13] 
    ANTENNAPARTIALMETALAREA 0.579 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5476 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.778 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4672 LAYER M4 ;
  END result[13]
  PIN result[12] 
    ANTENNAPARTIALMETALAREA 0.019 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0836 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.176 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2624 LAYER M4 ;
  END result[12]
  PIN result[11] 
    ANTENNAPARTIALMETALAREA 0.379 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6676 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.1502 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 3.618 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.9632 LAYER M4 ;
  END result[11]
  PIN result[10] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.387 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1908 LAYER M3 ;
  END result[10]
  PIN result[9] 
    ANTENNAPARTIALMETALAREA 0.719 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1636 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.178 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2272 LAYER M4 ;
  END result[9]
  PIN result[8] 
    ANTENNADIFFAREA 0.077 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 0.727 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2868 LAYER M3 ;
  END result[8]
  PIN result[7] 
    ANTENNAPARTIALMETALAREA 0.459 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.838 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1312 LAYER M4 ;
  END result[7]
  PIN result[6] 
    ANTENNADIFFAREA 0.0678 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 0.627 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8468 LAYER M3 ;
  END result[6]
  PIN result[5] 
    ANTENNADIFFAREA 0.1502 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 0.029 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1716 LAYER M3 ;
  END result[5]
  PIN result[4] 
    ANTENNAPARTIALMETALAREA 1.059 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6596 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.238 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4912 LAYER M4 ;
  END result[4]
  PIN result[3] 
    ANTENNAPARTIALMETALAREA 1.439 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3316 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.718 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.6032 LAYER M4 ;
  END result[3]
  PIN result[2] 
    ANTENNADIFFAREA 0.0678 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.007 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5188 LAYER M3 ;
  END result[2]
  PIN result[1] 
    ANTENNAPARTIALMETALAREA 1.659 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2996 LAYER M3 ;
    ANTENNAPARTIALCUTAREA 0.01 LAYER VIA3 ;
    ANTENNADIFFAREA 0.077 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 1.178 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2272 LAYER M4 ;
  END result[1]
  PIN result[0] 
    ANTENNADIFFAREA 0.0678 LAYER M3 ; 
    ANTENNAPARTIALMETALAREA 1.007 LAYER M3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5188 LAYER M3 ;
  END result[0]
END oadm_dm

END LIBRARY
